# The original ssat recipe does not have a fixed SRCREV,
# we fix SRCREV of ssat for porting it on IoT Yocto.
SRCREV = "0b5f29ab7e1a53348523fc384752b4530a4e28b6"
